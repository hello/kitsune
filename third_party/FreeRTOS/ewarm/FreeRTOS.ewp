# IAR project FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\; ..\source\; ..\source\include; ..\source\portable\IAR\ARM_CM4; ..\source\portable\IAR\ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\; ..\source\; ..\source\include; ..\source\portable\IAR\ARM_CM4
  OBJCOPY.OOCOutputFile: fRTOS.srec
  ILINK.IlinkOutputFile: fRTOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: osi.c
  group source
    ../source/: croutine.c list.c queue.c tasks.c timers.c
  group source/portable/IAR/ARM_CM4
    ../source/portable/IAR/ARM_CM4/: port.c portasm.s
